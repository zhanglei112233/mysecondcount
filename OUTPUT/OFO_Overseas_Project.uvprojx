# Keil uVision project OFO_Overseas_Project.uvprojx, settings and files
target OFO_Overseas_Project (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: OFO_Overseas_Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 HARD_VER3
  c misc: --c99
  c include: ..\APP\include;..\Device\include;..\nRF_BLE\inc;..\nRF_Drivers\inc;..\nRF_Libraries\inc;..\nRF_SoftDevice\inc
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group APP
    ../APP/: main.c
    ../APP/source/: ofo_led.c ofo_adc.c ofo_wdt.c ofo_uart.c ofo_flash.c ofo_buzz.c ofo_date.c ofo_lock.c ofo_lis3dh.c ofo_ble_unlock.c ofo_key_unlock.c ofo_factory_test.c
  group Device
    ../Device/source/: arm_startup_nrf51.s system_nrf51.c
  group nRF_BLE
    ../nRF_BLE/src/: ble_advdata.c ble_advertising.c ble_conn_params.c ble_nus.c ble_srv_common.c
  group nRF_Drivers
    ../nRF_Drivers/src/: nrf_adc.c nrf_delay.c nrf_drv_common.c nrf_drv_gpiote.c nrf_drv_spi.c nrf_drv_uart.c nrf_drv_wdt.c pstorage.c twi_hw_master.c
  group nRF_Libraries
    ../nRF_Libraries/src/: app_error.c app_fifo.c app_scheduler.c app_timer.c app_trace.c nrf_assert.c retarget.c app_uart_fifo.c
  group nRF_SoftDevice
    ../nRF_SoftDevice/src/: softdevice_handler.c
software components: CMSIS:CORE 4.3.0
